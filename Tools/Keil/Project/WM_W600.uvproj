# Keil uVision project WM_W600.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: WM_W600 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=1
  c define: WM_W600 AYLA_FreeRTOS CONF_NO_ID_FILE XXD_BIN_TO_C LOG_LOCK AYLA_WIFI_SUPPORT AYLA_LAN_SUPPORT FLASH_CONF_CACHE  AYLA_BATCH_PROP_SUPPORT JV_CTRL AIRKISS
  c misc: --c99 --gnu
  c include: ..\..\..\Include;..\..\..\Src\Network\api;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Platform\Common\Params;..\..\..\Platform\Common\task;..\..\..\Platform\Common\mem;..\..\..\Platform\Common\fwup;..\..\..\Platform\Common\utils;..\..\..\Platform\Inc;..\..\..\Platform\Sys;..\..\..\Src\App\wm_atcmd;..\..\..\Src\App\demo;..\..\..\Src\App\dhcpserver;..\..\..\Src\App\dnsserver;..\..\..\Src\App\matrixssl;..\..\..\Src\App\matrixssl\crypto;..\..\..\Src\App\libupnp-1.6.19\ixml\inc;..\..\..\Src\App\libupnp-1.6.19\upnp\inc;..\..\..\Src\App\libupnp-1.6.19\ixml\include;..\..\..\Src\App\libupnp-1.6.19\threadutil\include;..\..\..\Src\App\libupnp-1.6.19\upnp\include;..\..\..\Src\App\gmediarender-0.0.6;..\..\..\Src\App\web;..\..\..\Src\App\cloud;..\..\..\Src\App\cJSON;..\..\..\Src\App\ajtcl-15.04.00a\inc;..\..\..\Src\App\ajtcl-15.04.00a\target\winnermicro;..\..\..\Src\App\ajtcl-15.04.00a\external\sha2;..\..\..\Src\App\cJSON;..\..\..\Src\App\cloud\Kii;..\..\..\Src\App\rmms;..\..\..\Demo;..\..\..\Src\App\ntp;..\..\..\Src\OS\OS_ports;..\..\..\Src\App\httpclient;..\..\..\Src\App\oneshotconfig;..\..\..\Lib;..\..\..\Src\App\iperf;..\..\..\Src\OS\uCOS-II;..\..\..\Src\OS\uCOS-II\ports;..\..\..\Src\OS\uCOS-II\source;..\..\..\Src\OS\RTOS\include;..\..\..\Platform\Common\crypto;..\..\..\Include\App;..\..\..\Include\Driver;..\..\..\Include\Net;..\..\..\Include\OS;..\..\..\Include\Platform;..\..\..\Include\WiFi;..\..\..\Src\App\matrixssl\core;..\..\..\Platform\Common\crypto\digest;..\..\..\Platform\Common\crypto\math;..\..\..\Platform\Common\crypto\symmetric;..\..\..\Src\App\mqtt;..\..\..\Src\App\iperf;..\..\..\Src\App\ping;..\..\..\Src\App\polarssl\include;..\..\..\Src\App\mDNS\mDNSPosix;..\..\..\Src\App\mDNS\mDNSCore;..\..\..\Src\Network\lwip2.0.3\include;..\..\..\Src\App\OTA;..\..\..\Src\App\libwebsockets-2.1-stable;..\..\..\ayla\libayla\include;..\..\..\ayla\libada\include;..\..\..\ayla\include;..\..\..\ayla\libnet\include;..\..\..\ayla\ayla_demo\src;..\..\..\ayla\ext\jsmn;..\..\..\ayla\libada;..\..\..\ayla\libnet\w600\include;..\..\..\Src\Network\lwip2.0.3\include\posix;..\..\..\Src\Network\lwip2.0.3;..\..\..\ayla\libadw\include;..\..\..\ayla\libadw;..\..\..\ayla\drivers
  asm include: ..\..\..\Include\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group main
    ../../../App/: main.c
  group Platform
    ../../../Platform/Boot/armcc/: startup_venus.s retarget.c misc.c
    ../../../Platform/Sys/: wm_main.c tls_sys.c
    ../../../Platform/Drivers/: wm_driver.c
    ../../../Platform/Common/: wm_common.c
  group demo
    ../../../Demo/: wm_uart_demo.c wm_gpio_demo.c wm_flash_demo.c wm_pwm_demo.c wm_master_spi_demo.c wm_rtc_demo.c wm_timer_demo.c wm_pmu_demo.c wm_crypt_hard_demo.c wm_rsa_demo.c wm_socket_client_demo.c wm_connect_net_demo.c wm_apsta_demo.c wm_softap_demo.c wm_ntp_demo.c wm_udp_demo.c wm_socket_server_demo.c wm_wps_demo.c wm_http_demo.c wm_i2c_demo.c wm_i2s_demo.c wm_websockets_demo.c wm_slave_spi_demo.c wm_ssl_server_demo.c
    ../../../Demo/console/: wm_demo_console_task.c
  group DhcpServer
    ../../../Src/App/dhcpserver/: dhcp_server.c
  group DnsServer
    ../../../Src/App/dnsserver/: dns_server.c
  group oneshotcfg
    ../../../Src/App/oneshotconfig/: wm_wifi_oneshot.c wm_oneshot_airkiss.c libairkiss_log.lib wm_oneshot_lsd.c
  group Cmd
    ../../../Src/App/wm_atcmd/: wm_cmd.c
  group OS
    ../../../Src/OS/RTOS/: wm_rtos.c
  group LWIP
    ../../../Src/Network/: lwip2.0.3.c lwip.c
  group NTP
    ../../../Src/App/ntp/: ntp_client.c
  group websocket
    ../../../Src/App/libwebsockets-2.1-stable/: base64-decode.c client.c client-handshake.c client-parser.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl.c ssl-client.c
  group libcoap
    ../../../Src/App/libcoap/: address.c async.c block.c coap_time.c debug.c encode.c hashkey.c option.c pdu.c resource.c str.c subscribe.c uri_libcoap.c mem_libcoap.c coap_io_lwip.c net.c
  group cJSON
    ../../../Src/App/cJSON/: cJSON.c
  group HttpClient
    ../../../Src/App/httpclient/: wm_http_compile.c
  group MQTT
    ../../../Src/App/mqtt/: libemqtt.c
  group PING
    ../../../Src/App/ping/: ping.c
  group MatrixSSL
    ../../../Src/App/matrixssl/: wm_matrixssl_compile.c
  group Iperf
    ../../../Src/App/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group polarssl
    ../../../Src/App/polarssl/library/: asn1parse.c base64.c cipher.c cipher_wrap.c error.c md.c md_wrap.c pem.c rsa.c ssl_cli.c ssl_tls.c x509parse.c polarssl_bignum.c polarssl_debug.c polarssl_md5.c polarssl_sha1.c arc4.c
  group mDNS
    ../../../Src/App/mDNS/mDNSPosix/: mDNSPosix.c
    ../../../Src/App/mDNS/mDNSCore/: mDNS.c
  group wlan_lib
    ../../../Lib/Wlan/: wlan.lib
  group OTA
    ../../../Src/App/OTA/: wm_http_fwup.c wm_socket_fwup.c
  group SSLServer
    ../../../Src/App/sslserver/: wm_ssl_server.c
  group WebServer
    ../../../Src/App/web/: fs.c httpd.c web.c
  group ayla_demo
    ../../../ayla/ayla_demo/src/: demo_common.c demo_conf.c demo_ledevb.c demo_sched.c demo_stub.c demo_wifi.c ota.c demo_batch.c
  group libada
    ../../../ayla/libada/al/w600/: ada_lock.c client_task.c conf_table.c http_client.c notify_task.c sched_conf.c server_w600.c stubs.c
    ../../../ayla/libada/certs/: ca_certs_der.c
    ../../../ayla/libada/text/: custom.css.c regtoken.html.c
    ../../../ayla/libada/: ada_conf.c ada_err.c client_auth.c client_ayla.c client_conf.c client_ota.c client_prop.c conf_json.c dnss.c dnss_util.c lan.c log_page.c notify.c oem.c prop_mgr.c prop_page.c sched.c schedeval.c server_mem.c server_req.c sprop.c sys_conf.c ame.c ame_json.c batch.c client_ame.c
  group libayla
    ../../../ayla/libayla/arch/w600/: clock.c conf_flash.c malloc.c
    ../../../ayla/libayla/: base64_ayla.c clock_fmt.c clock_sw.c clock_utils.c cmd_handle.c conf.c crc.c crc8.c crc16.c endian.c format_mac.c format_string.c hostname_valid.c http.c jsmn_get.c jsmn_iterate.c json_format_string.c log.c log_cmd.c log_conf.c log_io.c lookup_by_name.c lookup_by_val.c parse_argv.c parse_date.c parse_hex.c parse_mac.c parse_url.c timer.c uri_arg_allowed_map.c uri_decode.c uri_encode.c utf8.c xml.c xml_decode.c xml_encode.c
    ../../../ayla/ext/jsmn/: jsmn.c
  group libnet
    ../../../ayla/libnet/w600/: ipaddr_fmt.c net_crypto.c net_mbuf.c net_w600.c ssl_w600.c
    ../../../Lib/Wlan/: http_server.o
  group libadw
    ../../../ayla/libadw/text/: lock.gif.c refresh.gif.c wifi.html.c wifi.js.c
    ../../../ayla/libadw/: adw_wifi_conf.c wifi.c wifi_page.c wifi_w600.c
  group drives
    ../../../ayla/drivers/: device.c
    ../../../ayla/drivers/hal/: pin.c
    ../../../ayla/drivers/bsp/: drv_pin.c
